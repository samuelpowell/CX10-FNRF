# Keil uVision project cx10_fnrf.uvprojx, settings and files
target CX10 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F031K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: cx10_fnrf +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\Libraries\CMSIS\Include;.\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\src
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ./src/: main.c blinker.c MPU6050.c adc.c timer.c stm32f0xx_it.c system_stm32f0xx.c nrf24.c proto_blue.c proto_redv1.c motorpwm.c
  group lib
    ./Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_crc.c stm32f0xx_comp.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c stm32f0xx_misc.c stm32f0xx_syscfg.c
  group startup
    ./startup/: startup_stm32f0xx_mdk_arm.s
  group cfg
    ./src/: config.h
